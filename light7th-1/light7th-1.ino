
int pin[8] = {2,3,4,5,6,7,8,9};
int 123[]={
  {1,1,1,1,1,1,0,0},
  {0,1,1,0,0,0,0,0},
  {1,1,0,1,1,0,1,0},
  {1,1,1,1,0,0,1,0},
  {0,1,1,0,0,1,1,0},
  {1,0,1,1,0,1,1,0},
  {1,0,1,1,1,1,1,0},
  {1,1,1,0,0,1,0,0},
  {1,1,1,1,1,1,1,0},
  {1,1,1,0,0,1,1,0},
  } 
void setup() {
  for(int i=0;i<8;i++){
    pinMode(pin[i],OUTPUT);
  }

}

void loop() {
  char out[] = {3,3,4,5};
  for(int i=0;i<10;i++){
  for(int j=0;j<8)
    {
      digitalWrite(int(123[i][j]),LOW);
    }
    {
      digitalWrite(int(out[i][j-1]),HIGH);
    }
    delay(200);
  }
}
